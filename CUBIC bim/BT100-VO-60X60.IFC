Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: BT100-VO-60X60.IFC
Time: 2019-04-05T07:23:16
Author: com2it
Organization: Hewlett-Packard Company
Written by: SwIFC
Made in: SolidWorks 2015

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: BT100-EX-VO-60-A (2)
In: Default Storey
Name
BT100-EX-VO-60-A | PSet_Mass_Property - Mass Measure: 23.8324; Area Measure: 2.04799 m2; Volume Measure: 0.00305529 m3
BT100-EX-VO-60-A
